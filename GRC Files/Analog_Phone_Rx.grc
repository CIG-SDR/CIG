<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.6'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mpsk_stage6</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>[1.0 + 0.0j, ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>value</key><value>0.35</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>digital_diff_decoder_bb</key>
<param><key>id</key><value>digital_diff_decoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>digital_map_bb</key>
<param><key>id</key><value>digital_map_bb_0</value></param>
<param><key>map</key><value>[0,1]</value></param>
</block>
<block>
<key>digital_cma_equalizer_cc</key>
<param><key>id</key><value>digital_cma_equalizer_cc_0</value></param>
<param><key>num_taps</key><value>15</value></param>
<param><key>modulus</key><value>1</value></param>
<param><key>mu</key><value>eq_gain</value></param>
<param><key>sps</key><value>2</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>loop_bw</key><value>timing_loop_bw</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>2</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>2.4175e9</value></param>
<param><key>gain0</key><value>30</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>100e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>timing_loop_bw</value></param>
<param><key>label</key><value>Time: BW</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>0.2</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>controls@1: 0,0,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>eq_gain</value></param>
<param><key>label</key><value>Equalizer: rate</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>0.1</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>controls@1: 0,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_bw</value></param>
<param><key>label</key><value>Phase: Bandwidth</value></param>
<param><key>value</key><value>6.28/100.0</value></param>
<param><key>start</key><value>0.0</value></param>
<param><key>stop</key><value>1.0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>controls@1: 0,2,1,1</value></param>
</block>
<block>
<key>blocks_unpack_k_bits_bb</key>
<param><key>id</key><value>blocks_unpack_k_bits_bb_0</value></param>
<param><key>k</key><value>2</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0</value></param>
<param><key>check</key><value>True</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>home/vaibhav/Desktop/Phone_Rx</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>phase_bw</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>dsss_dsss_decoder_cc</key>
<param><key>id</key><value>dsss_dsss_decoder_cc_0</value></param>
<param><key>code</key><value>1, 1, 0, 1</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
</block>
<block>
<key>digital_psk_demod</key>
<param><key>id</key><value>digital_psk_demod_0</value></param>
<param><key>constellation_points</key><value>2</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>samples_per_symbol</key><value>2</value></param>
<param><key>excess_bw</key><value>0.10</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"none"</value></param>
</block>
<connection><source_block_id>digital_psk_demod_0</source_block_id><sink_block_id>digital_map_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_diff_decoder_bb_0</source_block_id><sink_block_id>blocks_unpack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_map_bb_0</source_block_id><sink_block_id>digital_diff_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_cma_equalizer_cc_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_cma_equalizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpack_k_bits_bb_0</source_block_id><sink_block_id>digital_crc32_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>dsss_dsss_decoder_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsss_dsss_decoder_cc_0</source_block_id><sink_block_id>digital_psk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
